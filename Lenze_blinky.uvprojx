# Keil uVision project Lenze_blinky.uvprojx, settings and files
target LenzeBlinky (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: Lenze_blinky +hex
  AfterMake: fromelf.exe .\Objects\Lenze_blinky.axf --i32combined --output .\bin\Lenze_blinky.hex
  AfterMake: fromelf -c -a -d -e -v -o Lenze_blinky.asm ./Objects/Lenze_blinky.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT5: ROM 0x1fff8000 size 0x1f40
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: .\bb_rom_sym_m0.txt
  group main
    ./: main.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
